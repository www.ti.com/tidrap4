{FBD}
{VERSION=1.1}
********************** Ferrite Bead Models **********************
* Last update: 2-27-98
* Copyright 1996, HyperLynx, Inc.
*
* Description of format:
* ----------------------
* {MANUFACTURER=<name>}
* - Sets the manufacturer name for all ensuing beads
* - <name> is limited to 12 characters; truncated if longer
* - Applies until superseded by another MANUFACTURER record
* - Must be a MANUFACTURER record before the first BEAD
*
* Example:
* {MANUFACTURER=DALE}
* ---------------------
* {BEAD=<name>
*  (R_DC=<resistance>)
*  (PT1=<freq>, <impedance>)
*  (PT2=<freq>, <impedance>)
*  (PT3=<freq>, <impedance>)
* }
* - BEAD=<name>  names the bead model; <name> is limited to 30 
*   characters
* - R_DC=<resistance>  gives the bead's DC resistance
* - PTx=<freq>, <impedance>  gives a frequency/impedance pair
*   for the bead
* - <freq> numbers can be scaled by a trailing 'M' or 'MHZ' to
*   give values in MegaHertz
* - Exactly 3 freq/Z pairs are required, as follows:
*   - The first point should be at (10-20)% of the nominal
*     impedance (nominal impedance is usually at 100 MHz)
*   - The last point should be the highest frequency shown in
*     the impedance v.s. frequency graph for the bead
*   - If the resonant point is available, it should be PT2.
*     If the resonant point is not available, the 2nd point
*     should generally be the impedance at the nominal bead
*     impedance indicated by the vendor (usually 100 Mhz).
*     If the nominal impedance and frequency are not specified,
*     then the 2nd point should be taken from the mid-point
*     of the Z-vs-freq graph for the bead
*
* WARNING: To provide accurate modeling, the data must following
*          the above rules.
*
* For example:
* {BEAD=ILB-1206-19
*  (R_DC=0.035)
*  (PT1=6.0MHZ,   4.0)
*  (PT2=100.0MHZ,19.0)
*  (PT3=500.0MHZ,27.0)
* }
*****************************************************************
{MANUFACTURER=SHORTED-BEAD}
{BEAD=SHORTED
 (R_DC=0.0001)
 (PT1=2.0MHZ,  .001)
 (PT2=1000.0MHZ,.010)
 (PT3=10000.0MHZ,.011)
}
*****************************************************************
{MANUFACTURER=ACT}
{BEAD=KCB-0805-120
 (R_DC=0.42)
 (PT1=2.0MHZ,   3.0)
 (PT2=100.0MHZ,120.0)
 (PT3=300.0MHZ,200.0)
}
*****************************************************************
{MANUFACTURER=DALE}
{BEAD=ILB-1206-19
 (R_DC=0.035)
 (PT1=6.0MHZ,   4.0)
 (PT2=100.0MHZ,19.0)
 (PT3=500.0MHZ,27.0)
}
{BEAD=ILB-1206-26
 (R_DC=0.035)
 (PT1=6.0MHZ,   6.0)
 (PT2=100.0MHZ,26.0)
 (PT3=500.0MHZ,41.0)
}
{BEAD=ILB-1206-31
 (R_DC=0.035)
 (PT1=6.5MHZ, 6.0)
 (PT2=100.0MHZ,31.0)
 (PT3=500.0MHZ,39.0)
}
{BEAD=ILB-1206-50
 (R_DC=0.07)
 (PT1=10.0MHZ, 14.0)
 (PT2=100.0MHZ,50.0)
 (PT3=500.0MHZ,80.0)
}
{BEAD=ILB-1206-70
 (R_DC=0.105)
 (PT1=10.0MHZ,  22.0)
 (PT2=100.0MHZ, 70.0)
 (PT3=500.0MHZ,110.0)
}
{BEAD=ILB-1206-120
 (R_DC=0.14)
 (PT1=10.0MHZ,  30.0)
 (PT2=100.0MHZ,120.0)
 (PT3=500.0MHZ,170.0)
}
{BEAD=ILB-1206-150
 (R_DC=0.14)
 (PT1=10.0MHZ,  45.0)
 (PT2=350.0MHZ,210.0)
 (PT3=500.0MHZ,200.0)
}
{BEAD=ILB-1206-300
 (R_DC=0.21)
 (PT1=10.0MHZ,  70.0)
 (PT2=150.0MHZ,300.0)
 (PT3=500.0MHZ,140.0)
}
{BEAD=ILB-1206-500
 (R_DC=0.35)
 (PT1=10.0MHZ, 120.0)
 (PT2=125.0MHZ,520.0)
 (PT3=500.0MHZ,210.0)
}
{BEAD=ILB-1206-600
 (R_DC=0.35)
 (PT1=10.0MHZ, 180.0)
 (PT2=100.0MHZ,670.0)
 (PT3=500.0MHZ,200.0)
}
*****************************************************************
{MANUFACTURER=DELEVAN}
{BEAD=4221-1
 (R_DC=0.0008)
 (PT1=10.0MHZ, 20.0)
 (PT2=100.0MHZ,47.0)
 (PT3=500.0MHZ,58.0)
}
{BEAD=4221-2
 (R_DC=0.0008)
 (PT1=10.0MHZ, 38.0)
 (PT2=100.0MHZ,95.0)
 (PT3=500.0MHZ,110.0)
}
{BEAD=4221-3
 (R_DC=0.0008)
 (PT1=10.0MHZ, 38.0)
 (PT2=100.0MHZ,42.0)
 (PT3=500.0MHZ,55.0)
}
{BEAD=4221-4
 (R_DC=0.0008)
 (PT1=10.0MHZ, 30.0)
 (PT2=100.0MHZ,85.0)
 (PT3=500.0MHZ,98.0)
}
******************************************************************
{MANUFACTURER=muRata}
***** SMD muRata *****
{BEAD=BLM11A121S-120
 (R_DC=0.140)
 (PT1=2.0MHZ,    10.0)
 (PT2=400.0MHZ, 180.0)
 (PT3=1000.0MHZ,140.0)
}
{BEAD=BLM11A221S-220
 (R_DC=0.210)
 (PT1=2.0MHZ,    20.0)
 (PT2=300.0MHZ, 275.0)
 (PT3=1000.0MHZ,165.0)
}
{BEAD=BLM11A601S-600
 (R_DC=0.490)
 (PT1=2.0MHZ,    50.0)
 (PT2=150.0MHZ, 750.0)
 (PT3=1000.0MHZ,180.0)
}
{BEAD=BLM21A121S-120
 (R_DC=0.420)
 (PT1=2.0MHZ,     5.0)
 (PT2=200.0MHZ, 180.0)
 (PT3=1000.0MHZ,105.0)
}
{BEAD=BLM21A401S-400
 (R_DC=0.700)
 (PT1=2.0MHZ,    40.0)
 (PT2=150.0MHZ, 410.0)
 (PT3=1000.0MHZ,140.0)
}
{BEAD=BLM21A601S-600
 (R_DC=1.050)
 (PT1=2.0MHZ,    90.0)
 (PT2=100.0MHZ, 650.0)
 (PT3=1000.0MHZ,120.0)
}
{BEAD=BLM21A102S-1000
 (R_DC=0.420)
 (PT1=2.0MHZ,   110.0)
 (PT2=75.0MHZ, 1080.0)
 (PT3=1000.0MHZ,110.0)
}
{BEAD=BLM31A260S-26
 (R_DC=0.140)
 (PT1=2.0MHZ,    4.0)
 (PT2=100.0MHZ, 26.0)
 (PT3=1000.0MHZ,31.0)
}
{BEAD=BLM31A700S-70
 (R_DC=0.350)
 (PT1=3.0MHZ,    4.0)
 (PT2=100.0MHZ, 70.0)
 (PT3=1000.0MHZ,85.0)
}
{BEAD=BLM31A601S-600
 (R_DC=0.700)
 (PT1=2.0MHZ,    80.0)
 (PT2=100.0MHZ, 620.0)
 (PT3=1000.0MHZ,120.0)
}
{BEAD=BLM41A800S-80
 (R_DC=0.210)
 (PT1=2.0MHZ,    7.0)
 (PT2=100.0MHZ, 85.0)
 (PT3=1000.0MHZ,95.0)
}
{BEAD=BLM41A151S-150
 (R_DC=0.490)
 (PT1=2.0MHZ,    10.0)
 (PT2=300.0MHZ, 175.0)
 (PT3=1000.0MHZ,140.0)
}
{BEAD=BLM11B750D-75
 (R_DC=0.420)
 (PT1=40.0MHZ,   20.0)
 (PT2=650.0MHZ, 310.0)
 (PT3=1000.0MHZ,275.0)
}
{BEAD=BLM11B141D-140
 (R_DC=0.490)
 (PT1=40.0MHZ,   40.0)
 (PT2=400.0MHZ, 640.0)
 (PT3=1000.0MHZ,200.0)
}
{BEAD=BLM11B421S-420
 (R_DC=0.490)
 (PT1=10.0MHZ,   40.0)
 (PT2=260.0MHZ, 725.0)
 (PT3=1000.0MHZ,200.0)
}
{BEAD=BLM11B601S-600
 (R_DC=0.540)
 (PT1=20.0MHZ,   100.0)
 (PT2=170.0MHZ, 1140.0)
 (PT3=1000.0MHZ, 170.0)
}
{BEAD=BLM11B102S-1000
 (R_DC=0.840)
 (PT1=20.0MHZ,   175.0)
 (PT2=140.0MHZ, 1250.0)
 (PT3=1000.0MHZ, 130.0)
}
{BEAD=BLM21B050S-5
 (R_DC=0.140)
 (PT1=40.0MHZ,    2.5)
 (PT2=100.0MHZ,   5.0)
 (PT3=1000.0MHZ, 28.0)
}
{BEAD=BLM21B201S-200
 (R_DC=0.490)
 (PT1=30.0MHZ,    50.0)
 (PT2=270.0MHZ,  890.0)
 (PT3=1000.0MHZ, 125.0)
}
{BEAD=BLM21B601S-600
 (R_DC=0.490)
 (PT1=10.0MHZ,    45.0)
 (PT2=160.0MHZ,  925.0)
 (PT3=1000.0MHZ, 130.0)
}
{BEAD=BLM21B751S-750
 (R_DC=0.490)
 (PT1=10.0MHZ,    65.0)
 (PT2=130.0MHZ, 1040.0)
 (PT3=1000.0MHZ, 160.0)
}
{BEAD=BLM21B102S-1000
 (R_DC=0.420)
 (PT1=10.0MHZ,    65.0)
 (PT2=130.0MHZ, 1300.0)
 (PT3=1000.0MHZ, 160.0)
}
{BEAD=BLM21B222S-2200
 (R_DC=0.560)
 (PT1=10.0MHZ,   150.0)
 (PT2=80.0MHZ,  2600.0)
 (PT3=1000.0MHZ,  75.0)
}
{BEAD=BLM31B601S-600
 (R_DC=0.700)
 (PT1=3.0MHZ,     40.0)
 (PT2=130.0MHZ,  640.0)
 (PT3=1000.0MHZ, 120.0)
}
{BEAD=BLM11P300S-30
 (R_DC=0.070)
 (PT1=4.0MHZ,      2.0)
 (PT2=100.0MHZ,   30.0)
 (PT3=1000.0MHZ,  38.0)
}
{BEAD=BLM11P600S-60
 (R_DC=0.140)
 (PT1=3.0MHZ,      5.0)
 (PT2=470.0MHZ,   89.0)
 (PT3=1000.0MHZ,  80.0)
}
{BEAD=BLM21P300S-30
 (R_DC=0.021)
 (PT1=4.0MHZ,      4.0)
 (PT2=700.0MHZ,   42.0)
 (PT3=1000.0MHZ,  38.0)
}
{BEAD=BLM31P500S-50
 (R_DC=0.021)
 (PT1=3.0MHZ,      4.0)
 (PT2=100.0MHZ,   50.0)
 (PT3=1000.0MHZ,  77.0)
}
{BEAD=BLM41P600S-60
 (R_DC=0.007)
 (PT1=2.0MHZ,      5.0)
 (PT2=430.0MHZ,   79.0)
 (PT3=1000.0MHZ,  68.0)
}
{BEAD=BLM41P750S-75
 (R_DC=0.021)
 (PT1=2.0MHZ,      6.0)
 (PT2=430.0MHZ,   97.0)
 (PT3=1000.0MHZ,  84.0)
}
{BEAD=BLM41P800S-80
 (R_DC=0.105)
 (PT1=2.0MHZ,      4.0)
 (PT2=300.0MHZ,   98.0)
 (PT3=1000.0MHZ,  85.0)
}
*** leaded muRata ***
{BEAD=BLO1RN1-A62
 (R_DC=0.010)
 (PT1=1.0MHZ,   5.0)
 (PT2=50.0MHZ, 60.0)
 (PT3=200.0MHZ,75.0)
}
{BEAD=BLO1RN1-A62B1
 (R_DC=0.010)
 (PT1=1.0MHZ,   5.0)
 (PT2=50.0MHZ, 60.0)
 (PT3=200.0MHZ,75.0)
}
{BEAD=BLO1RN1-A62T5
 (R_DC=0.010)
 (PT1=1.0MHZ,   5.0)
 (PT2=50.0MHZ, 60.0)
 (PT3=200.0MHZ,75.0)
}
{BEAD=BLO1RN1-A63T6
 (R_DC=0.010)
 (PT1=1.0MHZ,   5.0)
 (PT2=50.0MHZ, 60.0)
 (PT3=200.0MHZ,75.0)
}
{BEAD=BLO2RN1-A62
 (R_DC=0.010)
 (PT1=1.0MHZ,   5.0)
 (PT2=50.0MHZ, 60.0)
 (PT3=200.0MHZ,75.0)
}
{BEAD=BLO2RN2-A62
 (R_DC=0.010)
 (PT1=1.0MHZ,    12.0)
 (PT2=50.0MHZ,  125.0)
 (PT3=1000.0MHZ,160.0)
}
{BEAD=BLO2RN1-A62T4
 (R_DC=0.010)
 (PT1=1.0MHZ,   5.0)
 (PT2=50.0MHZ, 60.0)
 (PT3=200.0MHZ,75.0)
}
{BEAD=BLO2RN2-A62T4
 (R_DC=0.010)
 (PT1=1.0MHZ,    12.0)
 (PT2=50.0MHZ,  125.0)
 (PT3=1000.0MHZ,160.0)
}
{BEAD=BLO3RN2-R62
 (R_DC=0.010)
 (PT1=1.0MHZ,   7.0)
 (PT2=100.0MHZ,75.0)
 (PT3=200.0MHZ,80.0)
}
{BEAD=BLO3RN2-R62T4
 (R_DC=0.010)
 (PT1=1.0MHZ,   7.0)
 (PT2=100.0MHZ,75.0)
 (PT3=200.0MHZ,80.0)
}
******************************************************************
{MANUFACTURER=NIC Components}
{BEAD=NCBY201209-PKG0805
 (R_DC=0.07)
 (PT1=1.0MHZ,    0.4)
 (PT2=100.0MHZ, 18.0)
 (PT3=500.0MHZ, 31.0)
}
{BEAD=NCBY321611-PKG1206
 (R_DC=0.105)
 (PT1=1.0MHZ,   0.8)
 (PT2=100.0MHZ, 38.0)
 (PT3=500.0MHZ, 60.0)
}
{BEAD=NCBY322513-PKG1210
 (R_DC=0.14)
 (PT1=1.0MHZ,     1.4)
 (PT2=100.0MHZ,  75.0)
 (PT3=500.0MHZ, 120.0)
}
{BEAD=NCBY321616-PKG1206
 (R_DC=0.105)
 (PT1=1.0MHZ,     1.2)
 (PT2=100.0MHZ,  70.0)
 (PT3=500.0MHZ, 110.0)
}
{BEAD=NCBY451616-PKG1806
 (R_DC=0.14)
 (PT1=1.0MHZ,     1.8)
 (PT2=100.0MHZ, 100.0)
 (PT3=500.0MHZ, 170.0)
}
{BEAD=NCBY453215-PKG1812
 (R_DC=0.21)
 (PT1=1.0MHZ,     2.2)
 (PT2=100.0MHZ, 120.0)
 (PT3=500.0MHZ, 200.0)
}
{BEAD=NCBY423226-PKG1612
 (R_DC=0.0007)
 (PT1=1.0MHZ,     2.0)
 (PT2=100.0MHZ,  43.0)
 (PT3=500.0MHZ,  50.0)
}
{BEAD=NCBY863226-PKG3312
 (R_DC=0.0007)
 (PT1=1.0MHZ,     3.9)
 (PT2=100.0MHZ,  90.0)
 (PT3=500.0MHZ,  105.0)
}
{BEAD=NCBY784729-PKG3119
 (R_DC=0.0007)
 (PT1=1.0MHZ,     3.5)
 (PT2=100.0MHZ,  92.0)
 (PT3=500.0MHZ,  110.0)
}
******************************************************************
{MANUFACTURER=TDK}
{BEAD=ACB1608M-040-T
 (R_DC=0.3)
 (PT1=10.0MHZ,   6.0)
 (PT2=100.0MHZ, 40.0)
 (PT3=1000.0MHZ,70.0)
}
{BEAD=ACB1608M-080-T
 (R_DC=0.5)
 (PT1=10.0MHZ,   12.0)
 (PT2=100.0MHZ,  80.0)
 (PT3=1000.0MHZ,100.0)
}
{BEAD=ACB1608M-120-T
 (R_DC=0.7)
 (PT1=10.0MHZ,   20.0)
 (PT2=360.0MHZ, 180.0)
 (PT3=1000.0MHZ,100.0)
}
{BEAD=ACB1608M-300-T
 (R_DC=1.2)
 (PT1=10.0MHZ,   43.0)
 (PT2=190.0MHZ, 330.0)
 (PT3=1000.0MHZ, 90.0)
}
{BEAD=ACB1608M-600-T
 (R_DC=1.8)
 (PT1=10.0MHZ,  130.0)
 (PT2=100.0MHZ, 600.0)
 (PT3=1000.0MHZ, 80.0)
}
{BEAD=ACB2012M-040-T
 (R_DC=0.3)
 (PT1=10.0MHZ,    8.0)
 (PT2=100.0MHZ,  40.0)
 (PT3=1000.0MHZ, 60.0)
}
{BEAD=ACB2012M-080-T
 (R_DC=0.4)
 (PT1=10.0MHZ,    13.0)
 (PT2=400.0MHZ,  130.0)
 (PT3=1000.0MHZ, 100.0)
}
{BEAD=ACB2012M-150-T
 (R_DC=0.5)
 (PT1=10.0MHZ,    14.0)
 (PT2=440.0MHZ,  120.0)
 (PT3=1000.0MHZ, 100.0)
}
{BEAD=ACB2012M-300-T
 (R_DC=0.5)
 (PT1=10.0MHZ,    60.0)
 (PT2=190.0MHZ,  360.0)
 (PT3=1000.0MHZ,  90.0)
}
{BEAD=ACB2012M-600-T
 (R_DC=0.5)
 (PT1=10.0MHZ,   105.0)
 (PT2=100.0MHZ,  600.0)
 (PT3=1000.0MHZ,  70.0)
}
{BEAD=ACB3216M-600-T
 (R_DC=0.9)
 (PT1=10.0MHZ,   100.0)
 (PT2=440.0MHZ,  600.0)
 (PT3=1000.0MHZ,  60.0)
}
{BEAD=HF70ACC201209-T
 (R_DC=0.03)
 (PT1=10.0MHZ,   6.0)
 (PT2=100.0MHZ,  9.0)
 (PT3=900.0MHZ, 19.0)
}
{BEAD=HF50ACC201209-T
 (R_DC=0.03)
 (PT1=10.0MHZ,   3.9)
 (PT2=100.0MHZ, 11.0)
 (PT3=900.0MHZ, 25.0)
}
{BEAD=HF30ACC201209-T
 (R_DC=0.03)
 (PT1=17.0MHZ,    1.0)
 (PT2=180.0MHZ,  10.0)
 (PT3=1000.0MHZ, 30.0)
}
{BEAD=HF70ACC321611-T
 (R_DC=0.04)
 (PT1=10.0MHZ,  18.0)
 (PT2=100.0MHZ, 30.0)
 (PT3=900.0MHZ, 39.0)
}
{BEAD=HF50ACC321611-T
 (R_DC=0.04)
 (PT1=10.0MHZ,   8.0)
 (PT2=100.0MHZ, 31.0)
 (PT3=900.0MHZ, 57.0)
}
{BEAD=HF30ACC321611-T
 (R_DC=0.04)
 (PT1=10.0MHZ,   1.6)
 (PT2=200.0MHZ, 30.0)
 (PT3=900.0MHZ, 70.0)
}
{BEAD=HF70ACC322513-T
 (R_DC=0.05)
 (PT1=10.0MHZ,   33.0)
 (PT2=100.0MHZ,  51.0)
 (PT3=1000.0MHZ, 60.0)
}
{BEAD=HF50ACC322513-T
 (R_DC=0.05)
 (PT1=10.0MHZ,   14.0)
 (PT2=100.0MHZ,  90.0)
 (PT3=1000.0MHZ, 78.0)
}
{BEAD=HF30ACC322513-T
 (R_DC=0.05)
 (PT1=10.0MHZ,   25.0)
 (PT2=100.0MHZ,  30.0)
 (PT3=900.0MHZ, 101.0)
}
{BEAD=HF70ACC453215-T
 (R_DC=0.05)
 (PT1=10.0MHZ,   70.0)
 (PT2=200.0MHZ, 101.0)
 (PT3=1000.0MHZ, 90.0)
}
{BEAD=HF50ACC453215-T
 (R_DC=0.05)
 (PT1=10.0MHZ,   21.0)
 (PT2=310.0MHZ, 180.0)
 (PT3=900.0MHZ, 110.0)
}
{BEAD=HF30ACC453215-T
 (R_DC=0.05)
 (PT1=10.0MHZ,     5.8)
 (PT2=500.0MHZ,  200.0)
 (PT3=1000.0MHZ, 130.0)
}
{BEAD=HF70ACC575018-T
 (R_DC=0.04)
 (PT1=10.0MHZ,   90.0)
 (PT2=200.0MHZ, 170.0)
 (PT3=900.0MHZ, 100.0)
}
{BEAD=HF50ACC575018-T
 (R_DC=0.04)
 (PT1=10.0MHZ,   50.0)
 (PT2=200.0MHZ, 210.0)
 (PT3=900.0MHZ, 100.0)
}
{BEAD=HF30ACC575018-T
 (R_DC=0.04)
 (PT1=10.0MHZ,   7.0)
 (PT2=390.0MHZ, 240.0)
 (PT3=900.0MHZ, 130.0)
}
******************************************************************
{MANUFACTURER=TOKIN}
{BEAD=N1608Z300
 (R_DC=0.03)
 (PT1=1.0MHZ,    0.4)
 (PT2=100.0MHZ, 30.0)
 (PT3=1000.0MHZ,70.0)
}
{BEAD=N1608Z800
 (R_DC=0.045)
 (PT1=10.0MHZ,   10.0)
 (PT2=100.0MHZ,  80.0)
 (PT3=2000.0MHZ,250.0)
}
{BEAD=N1608Z121
 (R_DC=0.07)
 (PT1=1.0MHZ,     1.5)
 (PT2=100.0MHZ, 120.0)
 (PT3=600.0MHZ, 270.0)
}
{BEAD=N1608Z301
 (R_DC=0.10)
 (PT1=10.0MHZ,   30.0)
 (PT2=100.0MHZ, 300.0)
 (PT3=300.0MHZ, 500.0)
}
{BEAD=N1608Z601
 (R_DC=0.15)
 (PT1=10.0MHZ,   60.0)
 (PT2=100.0MHZ, 600.0)
 (PT3=300.0MHZ, 800.0)
}
{BEAD=N1608Z102
 (R_DC=0.23)
 (PT1=10.0MHZ,  100.0)
 (PT2=150.0MHZ,1000.0)
 (PT3=800.0MHZ, 350.0)
}
{BEAD=N1608ZA300
 (R_DC=0.09)
 (PT1=10.0MHZ,   15.0)
 (PT2=100.0MHZ,  35.0)
 (PT3=1000.0MHZ, 40.0)
}
{BEAD=N1608ZA800
 (R_DC=0.12)
 (PT1=10.0MHZ,  50.0)
 (PT2=100.0MHZ, 90.0)
 (PT3=900.0MHZ,100.0)
}
{BEAD=N1608ZA121
 (R_DC=0.14)
 (PT1=10.0MHZ,   50.0)
 (PT2=100.0MHZ, 120.0)
 (PT3=1000.0MHZ,150.0)
}
{BEAD=N1608ZA221
 (R_DC=0.20)
 (PT1=10.0MHZ,   85.6)
 (PT2=100.0MHZ, 220.0)
 (PT3=1000.0MHZ,300.0)
}
{BEAD=N1608ZA331
 (R_DC=0.30)
 (PT1=10.0MHZ,   120.0)
 (PT2=100.0MHZ,  330.0)
 (PT3=300.0MHZ,  400.0)
}
{BEAD=N1608ZA601
 (R_DC=0.50)
 (PT1=10.0MHZ,   250.0)
 (PT2=100.0MHZ,  600.0)
 (PT3=300.0MHZ,  600.0)
}
{BEAD=N1608ZA102
 (R_DC=0.7)
 (PT1=10.0MHZ,  550.0)
 (PT2=60.0MHZ, 1000.0)
 (PT3=100.0MHZ,1000.0)
}
{BEAD=N1608ZA202
 (R_DC=0.95)
 (PT1=10.0MHZ,   650.0)
 (PT2=70.0MHZ,  2000.0)
 (PT3=1000.0MHZ, 300.0)
}
{BEAD=N1608ZE101
 (R_DC=0.11)
 (PT1=10.0MHZ,   60.0)
 (PT2=100.0MHZ, 100.0)
 (PT3=400.0MHZ, 110.0)
}
{BEAD=N1608ZE221
 (R_DC=0.25)
 (PT1=10.0MHZ,   130.0)
 (PT2=100.0MHZ,  220.0)
 (PT3=1000.0MHZ, 100.0)
}
{BEAD=N1608ZE471
 (R_DC=0.40)
 (PT1=2.0MHZ,   120.0)
 (PT2=100.0MHZ, 470.0)
 (PT3=900.0MHZ, 150.0)
}
{BEAD=N1608ZE681
 (R_DC=0.63)
 (PT1=5.0MHZ,   400.0)
 (PT2=100.0MHZ, 495.0)
 (PT3=300.0MHZ, 250.0)
}
{BEAD=N2012Z260
 (R_DC=0.01)
 (PT1=1.0MHZ,     0.3)
 (PT2=100.0MHZ,  26.0)
 (PT3=1000.0MHZ, 60.0)
}
{BEAD=N2012Z121
 (R_DC=0.05)
 (PT1=10.0MHZ,    14.0)
 (PT2=80.0MHZ,   120.0)
 (PT3=1000.0MHZ, 220.0)
}
{BEAD=N2012Z221
 (R_DC=0.07)
 (PT1=10.0MHZ,    30.0)
 (PT2=100.0MHZ,  220.0)
 (PT3=600.0MHZ,  400.0)
}
{BEAD=N2012Z301
 (R_DC=0.06)
 (PT1=10.0MHZ,   30.0)
 (PT2=100.0MHZ, 300.0)
 (PT3=400.0MHZ, 500.0)
}
{BEAD=N2012Z601
 (R_DC=0.1)
 (PT1=10.0MHZ,    60.0)
 (PT2=100.0MHZ,  600.0)
 (PT3=300.0MHZ,  800.0)
}
{BEAD=N2012Z102
 (R_DC=0.15)
 (PT1=10.0MHZ,   80.0)
 (PT2=150.0MHZ,1000.0)
 (PT3=1000.0MHZ,300.0)
}
{BEAD=N2012Z202
 (R_DC=0.24)
 (PT1=10.0MHZ,  120.9)
 (PT2=80.0MHZ, 2000.0)
 (PT3=1000.0MHZ,200.0)
} 
{BEAD=N2012ZA400
 (R_DC=0.01)
 (PT1=10.0MHZ,   10.0)
 (PT2=100.0MHZ,  40.0)
 (PT3=1000.0MHZ, 50.0)
}
{BEAD=N2012ZA800
 (R_DC=0.04)
 (PT1=10.0MHZ,   30.0)
 (PT2=100.0MHZ,  80.0)
 (PT3=1000.0MHZ,110.0)
}
{BEAD=N2012ZA121
 (R_DC=0.045)
 (PT1=10.0MHZ,   35.0)
 (PT2=100.0MHZ, 120.0)
 (PT3=1000.0MHZ,180.0)
}
{BEAD=N2012ZA221
 (R_DC=0.08)
 (PT1=10.0MHZ,   60.0)
 (PT2=100.0MHZ, 220.0)
 (PT3=400.0MHZ, 300.0)
}
{BEAD=N2012ZA601
 (R_DC=0.15)
 (PT1=10.0MHZ,   200.0)
 (PT2=150.0MHZ,  600.0)
 (PT3=1000.0MHZ, 300.0)
}
{BEAD=N2012ZA102
 (R_DC=0.18)
 (PT1=10.0MHZ,   330.0)
 (PT2=80.0MHZ,  1000.0)
 (PT3=1000.0MHZ, 200.0)
}
{BEAD=N2012ZA202
 (R_DC=0.22)
 (PT1=10.0MHZ,   600.0)
 (PT2=50.0MHZ,  2000.0)
 (PT3=1000.0MHZ, 200.0)
}
{BEAD=N2012ZE101
 (R_DC=0.04)
 (PT1=2.0MHZ,    20.0)
 (PT2=100.0MHZ, 100.0)
 (PT3=600.0MHZ, 110.0)
}
{BEAD=N2012ZE221
 (R_DC=0.08)
 (PT1=3.0MHZ,    60.0)
 (PT2=310.0MHZ, 180.0)
 (PT3=900.0MHZ, 110.0)
}
{BEAD=N2012ZE471
 (R_DC=0.17)
 (PT1=3.0MHZ,    150.0)
 (PT2=150.0MHZ,  300.0)
 (PT3=700.0MHZ,  100.0)
}
{BEAD=N2012ZE681
 (R_DC=0.38)
 (PT1=2.0MHZ,   140.0)
 (PT2=70.0MHZ,  700.0)
 (PT3=900.0MHZ,  60.0)
}
{BEAD=N3216Z800
 (R_DC=0.1)
 (PT1=10.0MHZ,    40.0)
 (PT2=100.0MHZ,   80.0)
 (PT3=1000.0MHZ, 100.0)
}
{BEAD=N3216Z151
 (R_DC=0.14)
 (PT1=10.0MHZ,  65.9)
 (PT2=100.0MHZ,150.0)
 (PT3=300.0MHZ,180.0)
}
{BEAD=N3216Z501
 (R_DC=0.38)
 (PT1=10.0MHZ,   220.0)
 (PT2=90.0MHZ,   500.0)
 (PT3=1000.0MHZ, 200.0)
}
{BEAD=N3216Z122
 (R_DC=0.59)
 (PT1=10.0MHZ,  500.0)
 (PT2=60.0MHZ, 1200.0)
 (PT3=1000.0MHZ,180.0)
}
{BEAD=N3216Z202
 (R_DC=0.96)
 (PT1=10.0MHZ,  1000.0)
 (PT2=40.0MHZ,  2000.0)
 (PT3=500.0MHZ,  300.0)
}
{BEAD=N2012ZP600
 (R_DC=0.01)
 (PT1=10.0MHZ,   9.0)
 (PT2=100.0MHZ, 60.0)
 (PT3=600.0MHZ,100.0)
}
{BEAD=N3216ZP500
 (R_DC=0.01)
 (PT1=10.0MHZ,    6.0)
 (PT2=100.0MHZ,  50.0)
 (PT3=1000.0MHZ,100.0)
}
{BEAD=N4516Z600
 (R_DC=0.007)
 (PT1=10.0MHZ,    6.0)
 (PT2=100.0MHZ,  80.0)
 (PT3=1000.0MHZ,110.0)
}
{BEAD=N4516Z800
 (R_DC=0.03)
 (PT1=10.0MHZ,    7.5)
 (PT2=100.0MHZ, 100.0)
 (PT3=1000.0MHZ,130.0)
}
{BEAD=N4516ZP600
 (R_DC=0.02)
 (PT1=10.0MHZ,    7.0)
 (PT2=100.0MHZ,  60.0)
 (PT3=1000.0MHZ,130.0)
}
{BEAD=N4532ZP121
 (R_DC=0.008)
 (PT1=10.0MHZ,   15.0)
 (PT2=100.0MHZ, 120.0)
 (PT3=1000.0MHZ,220.0)
}
{BEAD=N4532ZP132
 (R_DC=0.035)
 (PT1=10.0MHZ,    70.0)
 (PT2=70.0MHZ,  1300.0)
 (PT3=1000.0MHZ, 600.0)
}
{BEAD=N5750Z501
 (R_DC=0.01)
 (PT1=10.0MHZ,   30.0)
 (PT2=100.0MHZ, 500.0)
 (PT3=800.0MHZ, 100.0)
{END}
